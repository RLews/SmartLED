# Keil uVision project uC.uvprojx, settings and files
target uC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\ApplicationLayer\inc;..\ComplexDriverLayer\inc;..\HardwareAbstractionLayer\inc;..\HardwareDriverLayer\inc;..\HardwareDriverLayer\STM32F10x_FWLib\inc;..\ServicesLayer\osal\inc;..\ServicesLayer\DataStructOpt\inc;..\ServicesLayer\Communication\inc;..\ServicesLayer\Gizwits;..\ServicesLayer\Gizwits\Utils;..\ServicesLayer\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group AppSrc
    ../ApplicationLayer/src/: app_led.c uC.c app_wifi.c app_shock.c app_led_ctrl.c
  group AppInc
    ../ApplicationLayer/inc/: app_led.h uC.h app_public.h app_wifi.h app_shock.h app_led_ctrl.h
  group OsalSrc
    ../ServicesLayer/osal/src/: osal.c
  group OsalInc
    ../ServicesLayer/osal/inc/: osal.h
  group HalSrc
    ../HardwareAbstractionLayer/src/: hal.c hal_int.c hal_led.c hal_timer.c hal_uart.c hal_wdg.c hal_rtc.c hal_sd.c hal_key.c hal_adc.c
  group HalInc
    ../HardwareAbstractionLayer/inc/: hal.h hal_int.h hal_led.h hal_timer.h hal_uart.h hal_wdg.h hal_public.h hal_rtc.h hal_sd.h hal_key.h hal_adc.h
  group StdLib
    ../ServicesLayer/Lib/: std_lib.c std_lib.h
  group CommSrc
    ../ServicesLayer/Communication/src/: srv_comm.c srv_comm_check.c srv_wifi_comm.c
  group CommInc
    ../ServicesLayer/Communication/inc/: srv_comm.h srv_comm_check.h srv_wifi_comm.h
  group DataStructOptSrc
    ../ServicesLayer/DataStructOpt/src/: srv_queue.c
  group DataStructOptInc
    ../ServicesLayer/DataStructOpt/inc/: srv_queue.h
  group gizwits
    ../ServicesLayer/Gizwits/: gizwits_product.c gizwits_product.h gizwits_protocol.c gizwits_protocol.h
    ../ServicesLayer/Gizwits/Utils/: common.c common.h dataPointTools.c dataPointTools.h ringbuffer.c ringBuffer.h
  group DriverSrc
    ../HardwareDriverLayer/src/: core_cm3.c drv_dwt.c drv_gpio.c drv_int.c drv_timer.c drv_uart.c system_stm32f10x.c drv_wdg.c drv_sd.c drv_spi.c drv_rtc.c startup_stm32f10x_md.s drv_adc.c
  group DriverInc
    ../HardwareDriverLayer/inc/: core_cm3.h drv_dwt.h drv_gpio.h drv_int.h drv_timer.h drv_uart.h platforms.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.h drv_wdg.h drv_public.h drv_sd.h drv_spi.h drv_rtc.h drv_adc.h
  group StmLibSrc
    ../HardwareDriverLayer/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StmLibInc
    ../HardwareDriverLayer/STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
